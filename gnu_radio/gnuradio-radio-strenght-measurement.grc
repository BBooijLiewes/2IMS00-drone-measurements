options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bandwidth_size
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: freq_base*freq_slide
  states: {}
- name: freq_base
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: freq_slide
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '6000'
    value: '2410'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_base*samp_rate_slide
  states: {}
- name: samp_rate_base
  id: variable
  parameters:
    value: 200e5
  states: {}
- name: samp_rate_slide
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '2'
    value: '2'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blks2_packet_decoder_0
  id: blks2_packet_decoder
  parameters:
    access_code: ''
    threshold: '-1'
    type: float
  states: {state: disabled}
- name: blks2_packet_decoder_0_0
  id: blks2_packet_decoder
  parameters:
    access_code: ''
    threshold: '-1'
    type: float
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/james/Desktop/out.data
    type: complex
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {state: disabled}
- name: digital_ofdm_demod_0
  id: digital_ofdm_demod
  parameters:
    cp_length: '128'
    fft_length: '512'
    modulation: bpsk
    occupied_tones: '200'
    snr: '10'
    type: byte
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: bandwidth_size
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 40e6
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth_size
    ctrlpanel: 'True'
    fc: freq
    fftsize: '2048'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '8'
    taps: ''
    type: fff
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blks2_packet_decoder_0, '0', rational_resampler_xxx_0, '0']
- [blks2_packet_decoder_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_demod_0, '0', blks2_packet_decoder_0, '0']
- [digital_ofdm_demod_0, '0', blks2_packet_decoder_0_0, '0']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', blocks_correctiq_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', digital_ofdm_demod_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
